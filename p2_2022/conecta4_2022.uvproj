# Keil uVision project conecta4_2022.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: conecta4_2022
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Assembly
    ./: Startup.s
  group Includes
    ./: celda.h conecta4_2022.h tableros.h entrada.h pruebas.h eventos.h cola_asyn.h timer.h
  group Sources
    ./: conecta4_2022.c main.c entrada.c conecta4_2022_arm.s pruebas.c cola_asyn.c timer.c
