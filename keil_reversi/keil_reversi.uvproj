# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c cola_asyn.c timer.c cola_asyn.h eventos.h timer.h msg.h G_Alarm.c planificador.c G_Alarm.h planificador.h gpio.c gpio.h botones.c G_Boton.c botones.h G_Boton.h G_Power.h G_Power.c power.h power.c conecta4_2022.c entrada.c G_IO.c pruebas.c conecta4_2022.h entrada.h G_IO.h pruebas.h tableros.h conecta4_2022_arm.s RTC.c RTC.h SWI.s funciones_swi.h Uart0.c Uart0.h g_serie.c g_serie.h WD.c WD.h
